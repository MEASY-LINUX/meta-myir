# Use systemd-timesyncd, as in the MYD-JS8MPQ trimming policy.
RDEPENDS:${PN}:remove:myd-jmx95x-b0 = "ntp"

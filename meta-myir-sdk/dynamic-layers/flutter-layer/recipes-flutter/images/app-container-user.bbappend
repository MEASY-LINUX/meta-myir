# meta-flutter unpacks its files straight into S; Yocto >= 5.1 splits UNPACKDIR from WORKDIR.
S = "${UNPACKDIR}"

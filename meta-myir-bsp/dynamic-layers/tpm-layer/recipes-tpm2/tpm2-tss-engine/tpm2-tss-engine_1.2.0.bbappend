FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:myd-jmx95x-b0 = " file://0001-Use-distributed-man-pages-without-pandoc.patch"

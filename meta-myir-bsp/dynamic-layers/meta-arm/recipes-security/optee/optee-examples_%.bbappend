# Build current meta-arm examples against the selected NXP OP-TEE TA SDK.
COMPATIBLE_MACHINE = "(myd-jmx95x-b0)"
